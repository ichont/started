# Keil uVision project PaperCounter.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: PaperCounter +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: i2c.c main.c
